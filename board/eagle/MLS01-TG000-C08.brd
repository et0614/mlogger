# Repository et0614/mlogger

File README.md:

# M-Logger

Materials for the production of M-Logger, an indoor thermal environment measurement device.

## Description

The M-Logger was developed with the objective of facilitating the measurement of the indoor thermal environment.
In order to evaluate the environment in question with the requisite degree of accuracy, it is necessary to measure
at least the dry bulb temperature, relative humidity, radiation temperature, and wind speed.
The cost of comprehensive instruments that measure these physical quantities is typically in excess of $1000.
Furthermore, they are bulky and challenging to install in multiple locations due to the necessity of a power outlet.
In contrast, the M-Logger is manufactured at a cost of less than $100, is compact and portable, and is powered
by two AA batteries.

Further information can be found in the accompanying
[paper](https://www.jstage.jst.go.jp/article/aijt/28/68/28_267/_article/-char/ja)
and [website](https://www.mlogger.jp).

## Repository layout

```
mlogger/
  hardware/       -- PCB, BOM, datasheets, enclosure
  firmware/       -- MCU firmware (MPLAB X projects)
  software/       -- .NET host applications + Python utilities
  docs/           -- Protocol specifications
```

### hardware/

| File / directory                 | Purpose                                                                |
| -------------------------------- | ---------------------------------------------------------------------- |
| `pcb/mlogger_main.f3z` ...       | Autodesk Fusion 360 PCB project files (main / TH probe / Vel probe).   |
| `pcb/*.png` , `*.pdf`            | Rendered board images and schematic PDFs for quick reference.          |
| `pcb/*_gerber.zip`               | Gerber package for PCBA outsourcing.                                   |
| `BOM.xlsx`                       | Bill of materials.                                                     |
| `datasheets/`                    | Datasheets for each mounted component.                                 |
| `enclosure/loggercase.3dm`       | Rhinoceros 3D model for the housing.                                   |

### firmware/

Firmware for the on-board MCU. MPLAB X IDE projects (the `.X` directory is MPLAB X's project format,
the successor to Atmel Studio). MCC (MPLAB Code Configurator) is used for peripheral initialization.

| Project                | Target MCU   | Role                                                       |
| ---------------------- | ------------ | ---------------------------------------------------------- |
| `mlogger_main.X/`      | AVR64DU32    | Main logger board firmware (sensors + radio + USB CDC).    |
| `mlogger_vel_probe.X/` | AVR64DU32    | Anemometer probe board firmware.                           |

The main board firmware speaks the **v4 protocol** (JSON-RPC style, line-delimited JSON over the
XBee/USB byte stream) defined in [`docs/protocol_v4.md`](docs/protocol_v4.md). Earlier firmware
revisions used a 3-character ASCII command set (referred to as v3); host applications below remain
backward-compatible with v3 hardware through a dedicated adapter so existing units keep working.

USB-CDC is also exposed as a side channel for diagnostics (RX frame dumps, dispatch traces, TX
status events) — extremely helpful when debugging Zigbee/BLE chunking and timing.

### software/

A Visual Studio solution covering three .NET 10 projects, plus a small set of Python utilities.

```
software/dotnet/MLSoftwares.sln
  MLLib/         -- shared protocol + transport abstraction (no UI)
  MLS_Mobile/    -- MAUI app for iPhone / Android (BLE to the device)
  MLServer/      -- Windows console application: Zigbee + BACnet + HTTP dashboard
software/python/
  test_protocol_v4.py  -- v4 smoke test over USB-CDC
  ble_trace.py         -- listen to USB-CDC diagnostic stream during BLE/Zigbee tests
  ...                  -- a handful of one-off helpers
```

Communication paths:

- **MLS_Mobile** — phone-side app, connects to one M-Logger at a time via Bluetooth LE
  (XBee 3 BLE GATT). Suitable for personal use or short measurement sessions.
- **MLServer** — runs on a Windows PC with a coordinator XBee on a serial port,
  receives streams from many M-Loggers over Zigbee in parallel, writes per-device CSV,
  publishes a JSON snapshot for an HTML dashboard, and exposes measurements as a BACnet
  device for integration with building automation systems.

Both applications speak the same `IMLProtocol` abstraction defined in `MLLib`. Two implementations
are provided:

- `JsonRpcV4Protocol` — talks the v4 JSON protocol to current firmware.
- `LegacyV3Protocol` — talks the older v3 ASCII protocol to existing devices that have not been
  re-flashed yet.

`ProtocolFactory.DetectAsync` probes the device at connect time (v3 `VER` then v4 `hello`) and
returns the matching protocol implementation, so callers do not branch on firmware version.

The .NET projects target `net10.0`. Building requires .NET 10 SDK; MLS_Mobile additionally needs the
MAUI workloads (`dotnet workload install maui-ios maui-android`).

### docs/

| File                | Contents                                                                   |
| ------------------- | -------------------------------------------------------------------------- |
| `protocol_v4.md`    | Specification of the v4 JSON-RPC communication protocol (commands/events). |

## License

Copyright Eisuke Togashi 2023.

This source describes Open Hardware and is licensed under the CERN-OHL-P v2. You may redistribute
and modify this documentation and make products using it under the terms of the
[CERN-OHL-P v2](https://cern.ch/cern-ohl). This documentation is distributed WITHOUT ANY EXPRESS OR
IMPLIED WARRANTY, INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A PARTICULAR
PURPOSE. Please see the CERN-OHL-P v2 for applicable conditions.

## Author

[Eisuke Togashi](https://www.mlogger.jp)

## EAGLE design board/eagle/MLS01-TG000-C08.brd

Parts:
B1: BATTERY +2.0 to +3.0V; PAD
C201, C202, C301, C302: 10u 25V 2012; C-2012/0805
C401, C601, C701, C802, C803, C807, C901B: 0.1u 50V 1608; C-1608/0603
C402: 1u 50V 1608; C-1608/0603
C804, C805: 16p 50V 1608; C-1608/0603
C806: UM; C-1608/0603
CA01: 0.1u 50V 1608; C-1608/0603
CB01: 0.1u 50V 1608; C-1608/0603
CB02: UM; C-1608/0603
CC01: 0.1u 50V 1608; C-1608/0603
CN601: PINHD-2X2; 2X02
CN602: PINHD-2X2/90; 2X02/90
D101: GS2JFL-TP; SODFL5629X125N
D801, D802: SML-D12D1WT86; SMD-1608
DC01: SML-D12D1WT86; SMD-1608
F101: MFU0603FF01000P500; FUSC1608X60N
IC201: XCL102D333CR-G; CL-2025-02_TOR
IC301: XCL102D503CR-G; CL-2025-02_TOR
IC401: TCR2EF20,LM; SOT23-5L
IC801: AVR32DB32; HVQFN32
IC901B: AHT20; PSON100P300X300X110-6N
ICA01: VCNL4030X01-GS08; VISHAY_VCNL4030X01-GS08
ICC01: XB3-24Z8CM-J; XCVR_XB3-24Z8CM-J
J701: TF-01; TF-01A
OP601: NJM4565M-TE1-#ZZZB; SOIC127P680X175-8N
PN801: Writer; MA04-1
PTC601: TFPT1206L1002FVPTC; C1206
Q601: MMBT5550LT1G; SOT95P237X111-3N
R601: 2.2R 1% 1608 1/10W; R-1608/0603
R602: 249R 1% 1608 1/10W; R-1608/0603
R603: TRIM_TC33X-2-101G
R604: 2.5k 1% 1608 1/10W; R-1608/0603
R605: 1.8k 1% 1608 1/10W; R-1608/0603
R606: 1.5k 1% 1608 1/10W; R-1608/0603
R607: SDT101BXN100DF
R802: UM; R-1608/0603
R803, R804: 510R 1608; R-1608/0603
RB01: UM; R-1608/0603
RC01: 510R 1608; R-1608/0603
RN801, RN901: EXB-28V103JX; RESCAXS50P200X100X45-8N
SJ801: SJ
SJB01: SJ
SV1: female; MA03-2-FEMALE
SV2: side-male; MA03-2-SIDE-MALE
SW101: SS-12D00G3
SW801: TVAF06-A020B-R
SWC01: TVAF06-A020B-R
U$4: P3T1570DP; TSSOP8
X801: FC-12M 32.7680KA-A5; X2-SMD-L2.0X1.2X0.55MM

Connections:
+2V: C402.P$1 (1), C802.P$1 (1), IC401.5 (VOUT), IC801.17 (PD7/VREFA)
+3V3: C202.P$2 (2), C701.P$1 (1), C803.P$1 (1), C807.P$1 (1), C901B.P$1 (1), CA01.P$1 (1), CB01.P$1 (1), CC01.P$1 (1), IC201.6 (VOUT), IC801.10 (VDDIO2), IC801.18 (AVDD), IC801.26 (PF6/!RESET), IC801.28 (VDD), IC901B.2 (VDD), ICA01.1 (VDD), ICA01.4 (IR-A), ICC01.2 (VCC), J701.4 (VDD), PN801.3, RN801.3 (1), RN801.4 (1), RN901.1, RN901.2 (1), RN901.3 (1), SV1.1, SV2.1, U$4.8 (VCC)
+5V: C302.P$2 (2), IC301.6 (VOUT), OP601.8 (V+), Q601.3 (C)
+5V_EN: IC301.3 (CE), IC801.2 (PA4), RN801.1
CS: IC801.9 (PC3/SS), J701.2 (CS)
GND: B1.2 (-), C201.P$1 (1), C202.P$1 (1), C301.P$1 (1), C302.P$1 (1), C401.P$2 (2), C402.P$2 (2), C601.P$2 (2), C701.P$2 (2), C802.P$2 (2), C803.P$2 (2), C804.P$2 (2), C805.P$2 (2), C806.P$2 (2), C807.P$2 (2), C901B.P$2 (2), CA01.P$2 (2), CB01.P$2 (2), CB02.P$2 (2), CC01.P$2 (2), CN601.3, D101.2 (A), D801.2 (C), D802.2 (C), DC01.2 (C), IC201.2 (GND_2), IC201.4 (GND_3), IC201.9 (GND), IC301.2 (GND_2), IC301.4 (GND_3), IC301.9 (GND), IC401.2 (GND), IC401.4 (NC), IC801.19 (GND1), IC801.29 (GND), IC801.EXP (EXPAD), IC901B.5 (GND), ICA01.3 (GND), ICC01.1 (GND), ICC01.10 (GND), ICC01.12 (GND), ICC01.21 (GND), ICC01.32 (GND), ICC01.34 (GND), J701.6 (VSS), OP601.4 (V-), PN801.1, R606.1, RN801.8 (2), SV1.5, SV2.5, SW801.2, SWC01.2, U$4.4 (GND), U$4.5 (A2), U$4.6 (A1), U$4.7 (A0)
GND_PIN: CN602.1, PTC601.1, R607.1
GPADI: IC801.24 (PF4), PN801.4
MISO: IC801.7 (PC1/MISO), J701.7 (DO)
MOSI: IC801.6 (PC0/MOSI), J701.3 (DI)
unnamed: D101.1 (C), F101.2, SW101.2
unnamed: CN602.3, R607.2
unnamed: CN601.4, R604.1
unnamed: RB01.1, SJB01.1, SV1.2
unnamed: IC201.5 (LX), IC201.8 (L2)
unnamed: IC301.5 (LX), IC301.8 (L2)
unnamed: IC801.5 (PA7), R804.2
unnamed: D802.1 (A), R804.1
unnamed: OP601.1 (OUT), OP601.2 (-IN), R802.2, SJ801.2
unnamed: ICC01.26 (ASSOCIATE/DIO5), RC01.2
unnamed: DC01.1 (A), RC01.1
unnamed: CN602.2, PTC601.2
unnamed: OP601.3 (+IN), R605.1, R606.2
unnamed: OP601.5 (+IN), R602.1, R603.2
unnamed: R603.3, R604.2
unnamed: IC801.4 (PA6), R803.1
unnamed: C601.P$1 (1), OP601.7 (OUT), Q601.1 (B), R605.2
unnamed: CN601.1, OP601.6 (-IN), R601.1
unnamed: IC801.1 (PA3), ICC01.30 (AD1/DIO1)
unnamed: IC801.15 (PD5), ICC01.24 (!CTS!/DIO7)
unnamed: IC801.16 (PD6), ICC01.27 (!RTS!/DIO6)
unnamed: C806.P$1 (1), IC801.12 (PD2), R802.1, SJ801.1
unnamed: B1.1 (+), F101.1
unnamed: Q601.2 (E), R601.2, R602.2
unnamed: ICA01.7 (INT), RN901.6 (2)
unnamed: D801.1 (A), R803.2
unnamed: IC801.32 (PA2), RN801.6 (2), SW801.1
unnamed: C804.P$1 (1), IC801.20 (PF0/XTAL32K2), X801.1
unnamed: C805.P$1 (1), IC801.21 (PF1/XTAL32K1), X801.2
unnamed: ICC01.31 (AD0/DIO0), RN801.5 (2), SWC01.1
unnamed: ICA01.5 (IR-C), ICA01.6 (LDR)
unnamed: CB02.P$1 (1), IC801.14 (PD4), RB01.2, SJB01.2
RXD: IC801.31 (PA1/RXD0), ICC01.3 (DOUT/DIO13)
SCK: IC801.8 (PC2/SCK), J701.5 (SCLK)
SCL: IC801.23 (PF3), IC901B.3 (SCL), ICA01.2 (SCL), RN901.8 (2), SV1.4, SV2.4, U$4.2 (SCL)
SDA: IC801.22 (PF2), IC901B.4 (SDA), ICA01.8 (SDA), RN901.7 (2), SV1.3, SV2.3, U$4.1 (SDA)
SLEEP: IC801.25 (PF5), ICC01.9 (!DTR!/SLEEP_RQ/DIO8)
TXD: IC801.30 (PA0/TXD0), ICC01.4 (DIN/!CONFIG!/DIO14)
UPID: IC801.27 (UPDI), PN801.2
VBAT: C201.P$2 (2), C301.P$2 (2), C401.P$1 (1), IC201.1 (VBAT), IC201.3 (CE), IC201.7 (L1), IC301.1 (VBAT), IC301.7 (L1), IC401.1 (VIN), IC401.3 (CTRL), SW101.3 (2)

Notes on the sheet:
24/03/03
ML-P01
M-Logger system proto type 08x
MLS01-TG000-C08
S.Yamaguchi
Main MCU
Xbee
Grove Temp. sensing
Iluminance sensing
Micro wind sensing
DCDC +5V
LDO +2V
DCDC +3V3
Power input
micro SD
E. Togashi
Rev.03
ダイオード接続先変更、汎用A/D入力追加、D101変更 IC901B追加
22/06/30
S. Yamaguchi
Temp. Humi. sensing
ICC01変更 XB3-24Z8PM-J→XB3-24Z8CM-J IC401 VINを+3.3VからVBATに変更、IC901A,C901A,R804削除 R803 249R→510Rに変更、RN801-4→RN901-4に変更
Rev.04
22/08/20
SWC01接続ピン変更 23→31ピン
22/10/20
Rev.05
Temp. sensing board
Micro wind sensing board
IC201, 202をXCL102シリーズに変更
Rev.08

Board: 2 copper layers, 120.5 x 59.0 mm, 64 parts (4 on the bottom side), 50 nets.

Other parts of the board:
U$2: SERIAL_NO
U$3: MLOGGER_LOGO

## EAGLE design board/eagle/mlogger.brd

Parts:
AM1: AVR64DB32-I/RXBVQFN32_RXB_MCH; VQFN32_RXB_MCH
BB1: BH321
C1, C2, C3, C4, C5, C6, C7, C8, C9: MURATA_0603; C0603
CLK1: 3.2768KHZ; X2-SMD-L2.0X1.2X0.55MM
D1, D2: 20V-1A; SOD-123
D3: OSHR1608C1A; C0603
HT1: HT77XXSOT23
HT2: HT77XXSOT25
J1: MICROSD-9P; MICRO-SD9+4P-SMD-16.1X14.5X1.85MM
L1, L2: 303010168_47UM_5X5MM; L2018
L3: LBR2012T100KIND_TAIYO_LBR2012_TAY; IND_TAIYO_LBR2012_TAY
OP1: NJM4565
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6: 1,6/0,8
PH1: VCNL4030X01
PN1: 3p-2.54; H3-2.54
PN2: B3B-PH-K-S
PN3: 2p-2.54; H2-2.54
PN4_1(XB1), PN4_2(XB1): 10p-2.0; H10-2.0
PTC1: TFPT1206
R1, R4, R5, R6, R7, R8: RES_0603; R0603
R239: R1005X4
RG1: TCR2EF20SOT-25___(SMV)_TOS; SOT-25___(SMV)_TOS
RL1: CPC1002N
SW1: SS-12D00G3
SW2, SW3: TVAF06-A020B-R
TH1: AHT20
TR1: MMBTA42
TRM1: TC33X-1-103EIND_1-103E-L; IND_1-103E-L

Connections:
ADC0: AM1.14 (PD4), PN2.P$2
ADC2: AM1.12 (PD2), OP1.P$1 (O1), OP1.P$2 (I-1)
CTS: AM1.1 (PA3), PN4_2(XB1).2
GADC1: AM1.24 (PF4), PAD5.1
GADC2: AM1.15 (PD5), PAD1.1
GADC3: AM1.13 (PD3), PAD2.1
GND: AM1.19 (GND_2), AM1.29 (GND_3), AM1.33 (GND), BB1.V- (-), C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, D3.2 (-), HT1.P$1 (GND), HT2.P$4 (GND), J1.6 (VSS), OP1.P$4 (V-), PAD6.1, PH1.GND, PN1.1, PN2.P$1, PN3.2, PN4_1(XB1).10, PTC1.P$1, R8.2, RG1.2, RL1.GND, SW2.P$2 (2), SW3.P$1 (1), TH1.P$5 (GND)
INT: PH1.INT, R239.4
MISO: AM1.7 (PC1,MISO), J1.7 (DO)
MOSI: AM1.6 (PC0,MOSI), J1.3 (DI)
unnamed: R4.2, TRM1.2 (3)
unnamed: AM1.20 (PF0(XTAL32K1)), C7.1, CLK1.1
unnamed: PN4_2(XB1).10, SW2.P$1 (1)
unnamed: AM1.16 (PD6), R1.2
unnamed: AM1.32 (PA2), SW3.P$2 (2)
unnamed: AM1.21 (PF1(XTAL32K2)), C8.1, CLK1.2
unnamed: C9.1, L3.2, RG1.5
unnamed: D3.1 (+), R1.1
unnamed: AM1.5 (PA7), PAD3.1
unnamed: AM1.4 (PA6), PAD4.1
unnamed: BB1.V+ (+), SW1.P$1 (P2)
unnamed: PH1.IRC, PH1.LDR
unnamed: AM1.2 (PA4), HT2.P$1 (CE)
unnamed: AM1.3 (PA5), RL1.+
unnamed: PTC1.P$2, R4.1
P$1: OP1.P$6 (I-2), PN3.1, R5.1
P$2: R5.2, R6.2, TR1.P$2
P$3: OP1.P$5 (I+2), R6.1, TRM1.3 (2)
P$5: C4.2, OP1.P$7 (O2), R7.1, TR1.P$1
P$6: OP1.P$8 (V+), RL1.DC-, TR1.P$3 (C)
P$7: OP1.P$3 (I+1), R7.2, R8.1
P$10: D2.+, HT2.P$5 (LX), L2.P$1
P$11: C3.2, L1.P$2, L2.P$2, SW1.P$2 (P1)
P$13: D1.+, HT1.P$2 (LX), L1.P$1
RXD: AM1.31 (PA1,RXD0), PN4_1(XB1).2
SCK: AM1.8 (PC2,SCK), J1.5 (SCLK)
SCL: AM1.23 (PF3), PH1.SCL, R239.2, TH1.P$3 (SCL)
SDA: AM1.22 (PF2), PH1.SDA, R239.8, TH1.P$4 (SDA)
SLP: AM1.25 (PF5), PN4_1(XB1).9
SS: AM1.9 (PC3,SS), J1.2 (CS)
TXD: AM1.30 (PA0,TXD0), PN4_1(XB1).3
UPDI: AM1.27 (UPDI), PN1.2
V5: C2.1, D2.-, HT2.P$2 (VOUT), RL1.DC+
VDD: AM1.10 (VDDIO2), AM1.18 (AVDD), AM1.28 (VDD), C1.1, C5.2, D1.-, HT1.P$3 (VOUT), J1.4 (VDD), PH1.IRA, PH1.VDD, PN1.3, PN2.P$3, PN4_1(XB1).1, R239.1, R239.3, R239.5, R239.7, RG1.1, RG1.3, TH1.P$2 (VDD)
VREFA: AM1.17 (PD7,VREFA), C6.2, L3.1

Notes on the sheet:
PH1
TH1

Board: 2 copper layers, 59.4 x 33.3 mm, 50 parts (1 on the bottom side), 45 nets.

## Code that names these connections

File firmware/mlogger_velocity_sensor_v03.X/mcc_generated_files/system/pins.h (part):

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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC3 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC3_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC3 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC3 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC3 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC2 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC2_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC2 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC2 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC2 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PF5 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PF5_SetInterruptHandler() method.
 *        This handler is called every time the IO_PF5 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PF5 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PF5 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PF6 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PF6_SetInterruptHandler() method.
 *        This handler is called every time the IO_PF6 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PF6 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PF6 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA0 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA0_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA0 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA0 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA0 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA2 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA2_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA2 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA2 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA2 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA3 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA3_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA3 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA3 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA3 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA4 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA4_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA4 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA4 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA4 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA5 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA5_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA5 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA5 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA5 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA6 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA6_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA6 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA6 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA6 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA7 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA7_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA7 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA7 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA7 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC0 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC0_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC0 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC0 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC0 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC1 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC1_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC1 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC1 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC1 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD2 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD2_SetInterruptHandler() method.
 *        This handler is called every time the IO_PD2 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PD2 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PD2 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD3 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD3_SetInterruptHandler() method.
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
File firmware/mlogger_th_sensor.X/mcc_generated_files/system/pins.h (part):

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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA0 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA0_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA0 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA0 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA0 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA1 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA1_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA1 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA1 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA1 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA4 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA4_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA4 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA4 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA4 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA5 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA5_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA5 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA5 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA5 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA6 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA6_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA6 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA6 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA6 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PA7 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PA7_SetInterruptHandler() method.
 *        This handler is called every time the IO_PA7 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PA7 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PA7 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC0 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC0_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC0 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC0 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC0 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC1 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC1_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC1 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC1 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC1 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC2 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC2_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC2 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC2 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC2 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PC3 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PC3_SetInterruptHandler() method.
 *        This handler is called every time the IO_PC3 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PC3 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PC3 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD2 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD2_SetInterruptHandler() method.
 *        This handler is called every time the IO_PD2 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PD2 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PD2 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD3 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD3_SetInterruptHandler() method.
 *        This handler is called every time the IO_PD3 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PD3 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PD3 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD4 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD4_SetInterruptHandler() method.
 *        This handler is called every time the IO_PD4 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PD4 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PD4 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD5 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD5_SetInterruptHandler() method.
 *        This handler is called every time the IO_PD5 ISR is executed. 
 * @pre PIN_MANAGER_Initialize() has been called at least once
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
/**
 * @ingroup  pinsdriver
 * @brief Interrupt Handler Setter for IO_PD5 pin input-sense-config functionality.
 *        Allows selecting an interrupt handler for IO_PD5 at application runtime
 * @pre PIN_MANAGER_Initialize() has been called at least once
 * @param InterruptHandler function pointer.
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
/**
 * @ingroup  pinsdriver
 * @brief Default Interrupt Handler for IO_PD7 pin. 
 *        This is a predefined interrupt handler to be used together with the IO_PD7_SetInterruptHandler() method.
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

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2021 Accelerated Designs. All rights reserved
COPYRIGHT: Copyright (C) 2022 Ultra Librarian. All rights reserved.
